<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STC071_USB_HID_CDC.ewp</path>
  </project>
  <batchBuild />
</workspace>
