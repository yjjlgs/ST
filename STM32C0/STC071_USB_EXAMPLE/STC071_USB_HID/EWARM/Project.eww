<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STC071_OFFICIAL_SIMPLE_EXAMPLE.ewp</path>
  </project>
  <batchBuild />
</workspace>
